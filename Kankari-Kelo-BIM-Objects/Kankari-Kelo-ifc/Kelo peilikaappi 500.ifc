Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-08-26T12:41:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 26 12:41:00 2024 * Host: Fazi * Database: C:\Users\INTERI~1\AppData\Local\Temp\0ce8c9f8-15da-47a3-844b-a844ad4c1d02\14407b8d-9b80-429d-a32d-441bbbbf4f4f\ifc * Database version: 5507 * Database creation date: Mon Aug 26 12:41:00 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 26 12:41:00 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 26 12:41:00 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFurnishingElement: Kelo peilikaapit:Kelo peilikaappi 500, Kelo peilikaapit:Kelo peilikaappi 500:380940
In: Level 1
Type - Material: Valkoinen, 0085 White, white
Type - Pset_FurnitureTypeCommon - Description: Leveys 500,600 ja 800
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kankari
Type - Pset_ProductRequirements - Category: Furniture
Material: white, Valkoinen, 0085 White, Default light, Mirror, Glass shelf
Pset_QuantityTakeOff - Reference: Kelo peilikaappi 500
