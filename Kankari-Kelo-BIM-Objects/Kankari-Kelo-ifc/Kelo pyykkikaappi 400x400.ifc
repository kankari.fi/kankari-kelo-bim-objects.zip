Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-08-26T12:46:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 26 12:46:07 2024 * Host: Fazi * Database: C:\Users\INTERI~1\AppData\Local\Temp\0ce8c9f8-15da-47a3-844b-a844ad4c1d02\1195e87d-9928-418e-9724-f9f8b9ed2d51\ifc * Database version: 5507 * Database creation date: Mon Aug 26 12:46:06 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 26 12:46:06 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 26 12:46:06 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFurnishingElement: Kelo pyykkikaapit:Kelo pyykkikaappi 400, Kelo pyykkikaapit:Kelo pyykkikaappi 400:388413
In: Level 1
Type - Material: Default Steel, Default White Laminate, white
Type - Pset_FurnitureTypeCommon - Description: Kaapissa kaksi koria ja kaksi hyllyä
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kankarin kaluste
Type - Pset_ProductRequirements - Category: Furniture
Material: white, Metal, Default White Laminate
Pset_QuantityTakeOff - Reference: Kelo pyykkikaappi 400
